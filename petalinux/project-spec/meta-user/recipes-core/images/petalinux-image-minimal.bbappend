IMAGE_INSTALL:append = " i2c-tools i2c-tools-dev i2c-tools-dbg "
