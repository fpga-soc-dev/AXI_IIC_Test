FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

HDF_URI = "file://pynq_z1_top.xsa"

