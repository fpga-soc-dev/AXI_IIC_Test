## yocto/meta-user/conf/machine/pynq-z1.conf
```bitbake
require conf/machine/zynq-generic.conf


IMAGE_BOOT_FILES = " \
		boot.bin \
		system.dtb \
		boot.scr \
		uImage \
		"
		
```
